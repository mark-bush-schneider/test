# Keil uVision project gpio.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: gpio
  c flags: Optim=1
  c include: ..\Source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Test
    ./: startup_stm32f4xx.s main.cpp
    ../Test/: system_stm32f4xx.c
  group Source
    ../Source/: classPushButton.h classGpio.cpp classGpio.h classLed.h
